# Keil uVision project Blinky.uvprojx, settings and files
target MKW41Z512xxx4 RAM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.5.0-dev1
  cpu: IRAM(0x1FFF8000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: CLOCK_SETUP=1
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target MKW41Z512xxx4 Flash (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.5.0-dev1
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: CLOCK_SETUP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
target MKW41Z512xxx4 MTB (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.5.0-dev1
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: CLOCK_SETUP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.0.0
